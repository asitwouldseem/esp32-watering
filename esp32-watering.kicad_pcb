# Repository asitwouldseem/esp32-watering

File README.md:

# esp32-watering
Project log for an ESP32 controlled watering system.

## Requirements
- Must be able to stand alone of Home Assistant. If HA goes offline for whatever reason, no plants should die! 
- Fault tolerant. Strive for professional, accept that I am merely a maker. 
- Ability to control water 'dosage' -- good plant parents know that watering shouldn't neccesarily be done on a schedule, and not all plants require watering consistently.
- Moisture sensors are out of scope. There are plenty of commercial solutions out there already. 
- Ability to detect when the storage tank runs dry and notify me.
- Packaged up in a neat, small profile package. No jiffy or (obviously) 3D printed jank. 
- Runs off USB-C. Probably 12V at this stage given the pumps and solenoids I'm seeing. 
- If possible, control from the ESP-32 D1 Mini form factor. I use a number of these prototyping boards already.
- Because I now have the "can design PCB" badge, assume order of 5 boards. Let's centralise as much as we can, but make the process reasonably repeatable if I want to run 2/3 zones down the track. 

## To Do
- Peristaltic pump to transfer the water from the tank to the plants
- Micro solenoids (NC) to control the flow to individual drippers (bonus points for daisy chained ones)
- Dripper heads + tube (preferably black)
- Float switch for water (simple circuit, only requires pull-down resistor)
- Container to store water
- Figure out pump flow rate -- we'll use this to set a default run time in ESPHome.
- Relays to control solenoid + pump. Could go with a H-bridge, but don't think we need PWM.
- Industrial design for box -- have seen cylindrical units.
- Most solenoids seem to run on 12V -- have plenty of sealed buck converters sitting around. Will break this out and have a 12V in and 5V in JST on the PCB.
- Will need a fuse, because maker paranoia.

More to follow!

## KiCad design esp32-watering.kicad_pcb

Parts:
D1, D2, D3, D4: 1N4004; D_DO-41_SOD81_P10.16mm_Horizontal
J1: 12V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: DS18B20; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Water Level; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Pump; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: Zone 1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Zone 2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: Zone 3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
K1: Pump Control; RELAY_SR5-12V-200-1C; PARTREV 1.01
K2: Zone 1; RELAY_SR5-12V-200-1C; PARTREV 1.01
K3: Zone 2; RELAY_SR5-12V-200-1C; PARTREV 1.01
K4: Zone 3; RELAY_SR5-12V-200-1C; PARTREV 1.01
Q1, Q2, Q3, Q4: 2N3904; TO-92_Inline
R1: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3, R4, R5: 1K6; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6: 4K7; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: esp32-wemos-d1-mini
U2: TSR 1-2433; TSR1-SINGLE_TRP

Connections:
+3.3V: J2.3, R1.2, R6.1, U1.16 (3V3), U2.3 (+VOUT)
+12V: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.1, J4.1, J5.1, J6.1, J7.1, K1.A2, K2.A2, K3.A2, K4.A2, U2.1 (+VIN)
GND: J1.2, J2.1, J3.2, K1.COM_2, K2.COM_2, K3.COM_2, K4.COM_2, Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (E), U1.1 (GND), U1.22 (GND), U1.33 (GND), U2.2 (GND)
unnamed: D1.2 (A), K1.A1, Q1.3 (C)
unnamed: D2.2 (A), K2.A1, Q2.3 (C)
unnamed: D3.2 (A), K3.A1, Q3.3 (C)
unnamed: D4.2 (A), K4.A1, Q4.3 (C)
unnamed: J4.2, K1.NO
unnamed: J5.2, K2.NO
unnamed: J6.2, K3.NO
unnamed: J7.2, K4.NO
unnamed: Q1.2 (B), R2.1
unnamed: Q2.2 (B), R3.1
unnamed: Q3.2 (B), R4.1
unnamed: Q4.2 (B), R5.1
Relay0: R2.2, U1.24 (IO_27)
Relay1: R3.2, U1.26 (IO_25)
Relay2: R4.2, U1.28 (IO_32)
Relay3: R5.2, U1.29 (IO_17/D3)
Sensor0: J3.1, R1.1, U1.31 (IO_16/D4)
Sensor1: J2.2, R6.2, U1.6 (IO_26/D0)

Notes on the sheet:
POWER
SENSORS

Board: 2 copper layers, 75.3 x 55.5 mm, 27 parts (0 on the bottom side), 21 nets.

## Commit log

2025-12-21 Create KiCad Project
2025-12-21 Move out of directory
2025-12-21 Update gitignore
2025-12-21 Add relays and ESP32
2025-12-21 Add pulldown resistor
2025-12-22 First pass of schematic. Three zones.
2025-12-22 Assign footprints
2025-12-22 Start layout
2025-12-22 More layout
2025-12-22 Indicative layout
2025-12-22 Initial layout
2025-12-22 Flip float valve
2025-12-23 Pre-DRC
2025-12-23 Pass DRC
2025-12-23 Change silkscreen note
2025-12-24 Add rounded corners to PCB
2025-12-24 DFM Check
2025-12-27 Add Dallas sensor + decoupling cap
2025-12-28 Add Traco 3.3V regulator
2025-12-28 Tidy ground plane
2025-12-28 Change silkscreen, refill zones
2025-12-28 Fix edge cut
2025-12-28 Join edge cuts DRC
2025-12-29 Remove ground pour under antenna
2025-12-29 V1.2 Change flyback diode location
2025-12-29 Align components, bump version
2025-12-29 Extend edge cut
2026-01-11 Submit to manufacture
2026-01-11 Create gerbers using toolkit
2026-01-11 Name nets
2026-01-17 Bump version, add b.silkscreen for polarity
2026-01-25 Bump version, fix manufacturing error
2026-06-07 Bump KiCAD version
